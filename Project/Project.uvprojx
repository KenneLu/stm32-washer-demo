# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --no-multibyte-chars
  c include: ..\Library;..\Library\Startup;..\User;..\User\App;..\User\App\Menu;..\User\App\Washer;..\User\Driver;..\User\Driver\Base;..\User\Driver\OLED;..\User\Driver\System;..\FreeRTOS\Inc;..\FreeRTOS\Port\MemMang;..\FreeRTOS\Port\RVDS\ARM_CM3;..\FreeRTOS\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Library
    ../Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group Library/Startup
    ../Library/Startup/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group User
    ../User/: main.c FreeRTOSConfig.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group User/App
    ../User/App/: Task_KeyScan.c Task_MainMenu.c Task_Manager.h Task_Start.c Task_Washer_Data.c Task_Washer_Error.c Task_Washer_Key.c Task_Washer_Pause.c Task_Washer_Run.c Task_Washer_Safety.c Task_Washer_Stop.c
  group User/App/Menu
    ../User/App/Menu/: Menu.c Menu.h Menu_Setting.c Menu_Washer.c
  group User/App/Washer
    ../User/App/Washer/: Washer.c Washer.h Washer_Data.c Washer_Data.h
  group User/Driver
    ../User/Driver/: Drv_Buzzer.c Drv_Buzzer.h Drv_DHT11.c Drv_DHT11.h Drv_Encoder.c Drv_Encoder.h Drv_Key.c Drv_Key.h Drv_LED.c Drv_LED.h Drv_MPU6050.c Drv_MPU6050.h Drv_MPU6050_Reg.h Drv_ServoMotor.c Drv_ServoMotor.h Drv_TB6612.c Drv_TB6612.h Drv_W25Q64.c Drv_W25Q64.h Drv_W25Q64_Ins.h
  group User/Driver/Base
    ../User/Driver/Base/: Drv_Debug.c Drv_AD.c Drv_AD.h Drv_I2C_HW.c Drv_I2C_HW.h Drv_PWM.c Drv_PWM.h Drv_SPI.c Drv_SPI.h Drv_USART.c Drv_USART.h
  group User/Driver/OLED
    ../User/Driver/OLED/: Drv_OLED.c Drv_OLED.h Drv_OLED_Data.h Drv_OLED_Data_ASCII.c Drv_OLED_Data_Hanzi.c Drv_OLED_Data_Image.c Drv_OLED_Patch_byAdam.c
  group User/Driver/System
    ../User/Driver/System/: Sys_Delay.c Sys_Delay.h Sys_Timer.c Sys_Timer.h
  group FreeRTOS/Inc
    ../FreeRTOS/Inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS/Port
    ../FreeRTOS/Port/MemMang/: heap_4.c
    ../FreeRTOS/Port/RVDS/ARM_CM3/: port.c portmacro.h
  group FreeRTOS/Src
    ../FreeRTOS/Src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
