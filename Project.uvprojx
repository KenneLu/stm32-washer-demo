# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --no-multibyte-chars
  c include: .\Start;.\Library;.\User;.\User;.\Menu;.\HardWare;.\System;.\OLED;.\Games
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group User
    ./User/: main.c
  group Menu
    ./Menu/: Menu.c Menu.h Menu_Data.c Menu_Setting.c Menu_Washer.c
  group HardWare
    ./HardWare/: Buzzer.c Buzzer.h DHT11.c DHT11.h Drv_Debug.c Drv_USART.c Drv_USART.h Encoder.c Encoder.h Key.c Key.h MPU6050.c MPU6050.h MPU6050_Reg.h MyAD.c MyAD.h MySPI.c MySPI.h PWM.c PWM.h ServoMotor.c ServoMotor.h TB6612.c TB6612.h W25Q64.c W25Q64.h W25Q64_Ins.h Washer.c Washer.h
  group System
    ./System/: Delay.c Delay.h Timer.c Timer.h
  group OLED
    ./OLED/: OLED.c OLED.h OLED_Data.h OLED_Data_ASCII.c OLED_Data_Hanzi.c OLED_Data_Image.c OLED_Patch_byAdam.c
  group Games
    ./Games/: Game_Of_Life.c Game_Of_Life.h Game_Snake.c Game_Snake.h Game_Snake_Data.h
